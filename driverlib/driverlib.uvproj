# Keil uVision project driverlib.uvproj, settings and files
target driverlib (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C129CNCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: driverlib (library)
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk
  c misc: --c99
  c include: ..\..\EmbbededSystemKeilProject
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ./: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Documentation
    ./: readme.txt
